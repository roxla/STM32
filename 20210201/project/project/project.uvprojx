# Keil uVision project project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\DRV\Beep;.\DRV\Led;.\DRV\Key;.\INCLUDE;.\SYSTEM\Systick;.\DRV\Timer;.\DRV\Pwm;.\DRV\Usart;.\DRV\Dht11;.\DRV\Ble;.\DRV\Sr04;.\DRV\Iic;.\DRV\Iwdg;.\DRV\Rtc;.\SYSTEM;.\DRV\Oled;.\DRV\Oled;.\DRV\Rc522;.\DRV\Spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
  group DRV
    ./DRV/Beep/: beep.c
    ./DRV/Key/: key.c
    ./DRV/Led/: led.c
    ./DRV/Timer/: timer.c
    ./DRV/Pwm/: pwm.c
    ./DRV/Usart/: usart.c
    ./DRV/Dht11/: dht11.c
    ./DRV/Ble/: ble.c
    ./DRV/Sr04/: sr04.c
    ./DRV/Iic/: iic.c
    ./DRV/Iwdg/: iwdg.c
    ./DRV/Rtc/: rtc.c
    ./DRV/Oled/: oled.c
    ./DRV/Spi/: spi.c
    ./DRV/Rc522/: rc522.c
  group SYSTEM
    ./SYSTEM/Systick/: systick.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
