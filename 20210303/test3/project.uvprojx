# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\DRIVER\LED;.\DRIVER\BEEP;.\DRIVER\BTN;.\SYSTEM\MY;.\SYSTEM\DELAY;.\SYSTEM\SYS;.\DRIVER\PWM;.\DRIVER\TIM;.\DRIVER\USART;.\DRIVER\SR04;.\DRIVER\DHT11;.\DRIVER\BLE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c
  group DRV
    ./DRIVER/LED/: led.c
    ./DRIVER/BTN/: btn.c
    ./DRIVER/BEEP/: beep.c
    ./DRIVER/TIM/: tim.c
    ./DRIVER/PWM/: pwm.c
    ./DRIVER/USART/: usart.c
    ./DRIVER/SR04/: sr04.c
    ./DRIVER/DHT11/: dht11.c
    ./DRIVER/BLE/: ble.c
  group SYS
    ./SYSTEM/DELAY/: systick.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
